options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: send_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_lin
  id: variable
  parameters:
    value: '100'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(150e3)
  states: {}
- name: sig_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: info_with_audio_mod_source_str2samp_0_0_0
  id: info_with_audio_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: hello world
    t: t
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    marker1: '0'
    name: '"The bits message"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '30'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_1_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', qtgui_time_sink_x_0_2_1, '0']
- [blocks_throttle2_1_0, '0', blocks_vco_f_0_0, '0']
- [blocks_vco_f_0_0, '0', low_pass_filter_0_0, '0']
- [hilbert_fc_1, '0', uhd_usrp_sink_0, '0']
- [info_with_audio_mod_source_str2samp_0_0_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [low_pass_filter_0_0, '0', hilbert_fc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
