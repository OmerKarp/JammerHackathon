options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: test_spoofing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Attacker_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: Rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '20'
  states: {}
- name: Tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e3)
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: jammer_spoofing_attack_0
  id: jammer_spoofing_attack
  parameters:
    fs: samp_rate
    msg: i am the champion
    t: t
    timeout: '0.2'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    marker1: '0'
    name: '"The bits message"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    name: '"jammer signal"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: Attacker_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_1_0_0, '0', blocks_vco_f_0_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', qtgui_time_sink_x_0_2_1, '0']
- [blocks_vco_f_0_0, '0', low_pass_filter_0_0, '0']
- [hilbert_fc_1, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [hilbert_fc_1, '0', uhd_usrp_sink_0_1_0, '0']
- [jammer_spoofing_attack_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [low_pass_filter_0_0, '0', hilbert_fc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
