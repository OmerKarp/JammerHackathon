options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: delay_attacker
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Attacker_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: Rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '20'
  states: {}
- name: Tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e3)
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: jammer_delay_attack_0
  id: jammer_delay_attack
  parameters:
    delay: '10'
    f1: '400'
    f2: '500'
    sample_rate: samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    name: '"before jamming"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    name: '"jammer signal"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: Attacker_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [jammer_delay_attack_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [jammer_delay_attack_0, '0', uhd_usrp_sink_0_1_0, '0']
- [uhd_usrp_source_0_0, '0', jammer_delay_attack_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
