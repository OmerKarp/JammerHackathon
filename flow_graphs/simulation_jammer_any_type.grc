options:
  parameters:
    generate_options: qt_gui
    id: jamming_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(100e3)
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '6000'
    chan_rate: samp_rate
    deviation: 1e3
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_add_const_vxx_1_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-2e3'
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_throttle2_1_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vco_f_0_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*math.pi*1e3
  states: {state: disabled}
- name: hilbert_fc_1_0
  id: hilbert_fc
  parameters:
    num_taps: '6500'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: jammer_barrage_0
  id: jammer_barrage
  parameters:
    Power: '1.0'
    end_freq: 20e3
    samp_rate: samp_rate
    start_freq: '-20e3'
  states: {}
- name: jammer_demod_samp2str_0
  id: jammer_demod_samp2str
  parameters:
    fs: samp_rate
    t: t
    timeout: '0.1'
    voltage: '1'
  states: {state: disabled}
- name: jammer_follwer_jammer_0
  id: jammer_follwer_jammer
  parameters:
    f1: 400e3
    f2: 500e3
  states: {state: disabled}
- name: jammer_mod_source_str2samp_0_0
  id: jammer_mod_source_str2samp
  parameters:
    fs: samp_rate
    msg: h
    t: t
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"before jamming"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"jammer signal"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"Rx"'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: serial=34D62B0
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_addr: serial=34D62B0
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_1, '0', jammer_demod_samp2str_0, '0']
- [blocks_add_const_vxx_1_0_0_0, '0', blocks_throttle2_1_0_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_1_0_0, '0', blocks_vco_f_0_0_0, '0']
- [blocks_vco_f_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [hilbert_fc_1_0, '0', uhd_usrp_sink_0_1, '0']
- [jammer_barrage_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [jammer_barrage_0, '0', uhd_usrp_sink_0_1_0, '0']
- [jammer_follwer_jammer_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [jammer_follwer_jammer_0, '0', uhd_usrp_sink_0_1_0, '0']
- [jammer_mod_source_str2samp_0_0, '0', blocks_add_const_vxx_1_0_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_1, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_1_0, '0']
- [low_pass_filter_0_0_0, '0', hilbert_fc_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0_0, '0', jammer_follwer_jammer_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
